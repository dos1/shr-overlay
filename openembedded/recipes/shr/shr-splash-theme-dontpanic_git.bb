DESCRIPTION = "SHR splash screen - DON'T PANIC theme"
SECTION = "x11/data"
LICENSE = "MIT BSD"
PV = "1.2-gitr${SRCPV}"
PR = "r0"

require "shr-splash-theme.inc"
