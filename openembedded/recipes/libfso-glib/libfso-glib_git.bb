DESCRIPTION = "GLib-based DBus bindings for freesmartphone.org - Vala implementation"
AUTHOR = "Didier 'Ptitjes"

PV = "0.0.1-gitr${SRCREV}"
PR = "r0"

SRC_URI = "git://git.freesmartphone.org/libfso-glib.git;protocol=git;branch=master"

inherit pkgconfig

